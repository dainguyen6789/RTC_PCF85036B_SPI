# Keil uVision project RTC_PCF85063B_Test.uvproj, settings and files
target A25LC040_Test (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: GPIO_RTC_Test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Application\Header
  group Header
    ./Application/Header/: a25lc040.h hc595.h STC15F2K60S2.H PCF85063BTL.h LCD_Driver_SPLC780D.h KeyPad.h VCNL4035X01.h Receiver_Position_Data.h SunPos.h PI4IOE5V96248.h
    ./: ADCh.h
  group Source
    ./Application/Source/: main.c PCF85063BTL.c UART1.c LCd_Driver_SPLC780D.c KeyPad.c ADC.c
    ./: BipolarMotor.c SunPos.c Calibration.c IOExpander_PI4IOE5V96248.c
  group StartUp
    ./Application/Startup/: STARTUP.A51
  group Doc
    ./Application/Doc/: readme.txt
